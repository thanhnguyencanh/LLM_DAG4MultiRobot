Commit message: change

File: my_objects/drawer/urdf/drawer.urdf (robot description, URDF)
Before this commit: robot drawer, 2 links, 1 joints
Links:
- added link world
Joints:
- added joint world_to_base: type fixed, parent world, child base_link, origin xyz=-0.6 0.25 0 rpy=0 0 0
